# IAR project uart_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10040; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74
  ICCARM.IExtraOptions: --diag_suppress Pe111
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\nRfLibs\components; ..\..\..\..\nRfLibs\components\boards; ..\..\..\..\nRfLibs\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\nRfLibs\components\libraries\atomic; ..\..\..\..\nRfLibs\components\libraries\balloc; ..\..\..\..\nRfLibs\components\libraries\bsp; ..\..\..\..\nRfLibs\components\libraries\delay; ..\..\..\..\nRfLibs\components\libraries\experimental_section_vars; ..\..\..\..\nRfLibs\components\libraries\fifo; ..\..\..\..\nRfLibs\components\libraries\log; ..\..\..\..\nRfLibs\components\libraries\log\src; ..\..\..\..\nRfLibs\components\libraries\memobj; ..\..\..\..\nRfLibs\components\libraries\ringbuf; ..\..\..\..\nRfLibs\components\libraries\strerror; ..\..\..\..\nRfLibs\components\libraries\uart; ..\..\..\..\nRfLibs\components\libraries\util; ..\..\..\..\nRfLibs\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\nRfLibs\external\fprintf; ..\..\..\..\nRfLibs\integration\nrfx; ..\..\..\..\nRfLibs\integration\nrfx\legacy; ..\..\..\..\nRfLibs\modules\nrfx; ..\..\..\..\nRfLibs\modules\nrfx\drivers\include; ..\..\..\..\nRfLibs\modules\nrfx\hal; ..\..\..\..\nRfLibs\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: uart_pca10040.hex
  ILINK.IlinkOutputFile: uart_pca10040.out
  ILINK.IlinkIcfFile: uart_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../nRfLibs/components/boards/: boards.c
  group None
    ../../../../nRfLibs/modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_Drivers
    ../../../../nRfLibs/integration/nrfx/legacy/: nrf_drv_uart.c
    ../../../../nRfLibs/modules/nrfx/soc/: nrfx_atomic.c
    ../../../../nRfLibs/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../nRfLibs/modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c
  group nRF_Libraries
    ../../../../nRfLibs/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../nRfLibs/components/libraries/fifo/: app_fifo.c
    ../../../../nRfLibs/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../nRfLibs/components/libraries/atomic/: nrf_atomic.c
    ../../../../nRfLibs/components/libraries/balloc/: nrf_balloc.c
    ../../../../nRfLibs/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../nRfLibs/components/libraries/memobj/: nrf_memobj.c
    ../../../../nRfLibs/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../nRfLibs/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../nRfLibs/components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
