# IAR project brlt_remote.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; NRF52; NRF52832_XXAA; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_64; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=4; S132; SOFTDEVICE_PRESENT; SWI_DISABLE0; MIR_KLIMATA
  ICCARM.CCIncludePath2: ..\config\ble_app_uart_c_pca10040_s132; ..\config; ..\config\firmware_for_update; ..\Core\Src; ..\Core\Src\ma_ble_protocol; ..\Core\Inc; ..\Drivers; ..\Drivers\ble\ble_advertising; ..\Drivers\ble\ble_db_discovery; ..\Drivers\ble\ble_dtm; ..\Drivers\ble\ble_racp; ..\Drivers\ble\ble_services\ble_ancs_c; ..\Drivers\ble\ble_services\ble_ans_c; ..\Drivers\ble\ble_services\ble_bas; ..\Drivers\ble\ble_services\ble_bas_c; ..\Drivers\ble\ble_services\ble_cscs; ..\Drivers\ble\ble_services\ble_cts_c; ..\Drivers\ble\ble_services\ble_dfu; ..\Drivers\ble\ble_services\ble_dis; ..\Drivers\ble\ble_services\ble_gls; ..\Drivers\ble\ble_services\ble_hids; ..\Drivers\ble\ble_services\ble_hrs; ..\Drivers\ble\ble_services\ble_hrs_c; ..\Drivers\ble\ble_services\ble_hts; ..\Drivers\ble\ble_services\ble_ias; ..\Drivers\ble\ble_services\ble_ias_c; ..\Drivers\ble\ble_services\ble_lbs; ..\Drivers\ble\ble_services\ble_lbs_c; ..\Drivers\ble\ble_services\ble_lls; ..\Drivers\ble\ble_services\ble_nus; ..\Drivers\ble\peer_manager; ..\Drivers\ble\ble_services\ble_nus_c; ..\Drivers\ble\ble_services\ble_rscs; ..\Drivers\ble\ble_services\ble_rscs_c; ..\Drivers\ble\ble_services\ble_tps; ..\Drivers\ble\common; ..\Drivers\ble\nrf_ble_gatt; ..\Drivers\ble\nrf_ble_qwr; ..\Drivers\ble\peer_manager; ..\Drivers\boards; ..\Drivers\device; ..\Drivers\drivers_nrf\clock; ..\Drivers\drivers_nrf\common; ..\Drivers\drivers_nrf\comp; ..\Drivers\drivers_nrf\delay; ..\Drivers\drivers_nrf\gpiote; ..\Drivers\drivers_nrf\hal; ..\Drivers\drivers_nrf\i2s; ..\Drivers\drivers_nrf\lpcomp; ..\Drivers\drivers_nrf\pdm; ..\Drivers\drivers_nrf\power; ..\Drivers\drivers_nrf\ppi; ..\Drivers\drivers_nrf\pwm; ..\Drivers\drivers_nrf\qdec; ..\Drivers\drivers_nrf\rng; ..\Drivers\drivers_nrf\rtc; ..\Drivers\drivers_nrf\saadc; ..\Drivers\drivers_nrf\spi_master; ..\Drivers\drivers_nrf\spi_slave; ..\Drivers\drivers_nrf\swi; ..\Drivers\drivers_nrf\timer; ..\Drivers\drivers_nrf\twi_master; ..\Drivers\drivers_nrf\twis_slave; ..\Drivers\drivers_nrf\uart; ..\Drivers\drivers_nrf\usbd; ..\Drivers\drivers_nrf\wdt; ..\Drivers\libraries\bsp; ..\Drivers\libraries\button; ..\Drivers\libraries\crc16; ..\Drivers\libraries\crc32; ..\Drivers\libraries\csense; ..\Drivers\libraries\csense_drv; ..\Drivers\libraries\ecc; ..\Drivers\libraries\experimental_section_vars; ..\Drivers\libraries\fds; ..\Drivers\libraries\fifo; ..\Drivers\libraries\fstorage; ..\Drivers\libraries\gpiote; ..\Drivers\libraries\hardfault; ..\Drivers\libraries\hci; ..\Drivers\libraries\led_softblink; ..\Drivers\libraries\log; ..\Drivers\libraries\log\src; ..\Drivers\libraries\low_power_pwm; ..\Drivers\libraries\mem_manager; ..\Drivers\libraries\pwm; ..\Drivers\libraries\queue; ..\Drivers\libraries\scheduler; ..\Drivers\libraries\slip; ..\Drivers\libraries\strerror; ..\Drivers\libraries\timer; ..\Drivers\libraries\twi; ..\Drivers\libraries\uart; ..\Drivers\libraries\usbd; ..\Drivers\libraries\usbd\class\audio; ..\Drivers\libraries\usbd\class\cdc; ..\Drivers\libraries\usbd\class\cdc\acm; ..\Drivers\libraries\usbd\class\hid; ..\Drivers\libraries\usbd\class\hid\generic; ..\Drivers\libraries\usbd\class\hid\kbd; ..\Drivers\libraries\usbd\class\hid\mouse; ..\Drivers\libraries\usbd\class\msc; ..\Drivers\libraries\usbd\config; ..\Drivers\libraries\util; ..\Drivers\libraries\fstorage; ..\Drivers\libraries\fds; ..\Drivers\softdevice\common\softdevice_handler; ..\Drivers\softdevice\s132\headers; ..\Drivers\softdevice\s132\headers\nrf52; ..\Drivers\toolchain; ..\Drivers\toolchain\cmsis\include; ..\Drivers\\external\segger_rtt
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; NRF52; NRF52832_XXAA; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_64; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=4; S132; SOFTDEVICE_PRESENT; SWI_DISABLE0
  AARM.AUserIncludes: ..\config\ble_app_uart_c_pca10040_s132; ..\config; ..\Core\Src; ..\Drivers; ..\Drivers\ble\ble_advertising; ..\Drivers\ble\ble_db_discovery; ..\Drivers\ble\ble_dtm; ..\Drivers\ble\ble_racp; ..\Drivers\ble\ble_services\ble_ancs_c; ..\Drivers\ble\ble_services\ble_ans_c; ..\Drivers\ble\ble_services\ble_bas; ..\Drivers\ble\ble_services\ble_bas_c; ..\Drivers\ble\ble_services\ble_cscs; ..\Drivers\ble\ble_services\ble_cts_c; ..\Drivers\ble\ble_services\ble_dfu; ..\Drivers\ble\ble_services\ble_dis; ..\Drivers\ble\ble_services\ble_gls; ..\Drivers\ble\ble_services\ble_hids; ..\Drivers\ble\ble_services\ble_hrs; ..\Drivers\ble\ble_services\ble_hrs_c; ..\Drivers\ble\ble_services\ble_hts; ..\Drivers\ble\ble_services\ble_ias; ..\Drivers\ble\ble_services\ble_ias_c; ..\Drivers\ble\ble_services\ble_lbs; ..\Drivers\ble\ble_services\ble_lbs_c; ..\Drivers\ble\ble_services\ble_lls; ..\Drivers\ble\ble_services\ble_nus; ..\Drivers\ble\ble_services\ble_nus_c; ..\Drivers\ble\ble_services\ble_rscs; ..\Drivers\ble\ble_services\ble_rscs_c; ..\Drivers\ble\ble_services\ble_tps; ..\Drivers\ble\common; ..\Drivers\ble\nrf_ble_gatt; ..\Drivers\ble\nrf_ble_qwr; ..\Drivers\ble\peer_manager; ..\Drivers\boards; ..\Drivers\device; ..\Drivers\drivers_nrf\clock; ..\Drivers\drivers_nrf\common; ..\Drivers\drivers_nrf\comp; ..\Drivers\drivers_nrf\delay; ..\Drivers\drivers_nrf\gpiote; ..\Drivers\drivers_nrf\hal; ..\Drivers\drivers_nrf\i2s; ..\Drivers\drivers_nrf\lpcomp; ..\Drivers\drivers_nrf\pdm; ..\Drivers\drivers_nrf\power; ..\Drivers\drivers_nrf\ppi; ..\Drivers\drivers_nrf\pwm; ..\Drivers\drivers_nrf\qdec; ..\Drivers\drivers_nrf\rng; ..\Drivers\drivers_nrf\rtc; ..\Drivers\drivers_nrf\saadc; ..\Drivers\drivers_nrf\spi_master; ..\Drivers\drivers_nrf\spi_slave; ..\Drivers\drivers_nrf\swi; ..\Drivers\drivers_nrf\timer; ..\Drivers\drivers_nrf\twi_master; ..\Drivers\drivers_nrf\twis_slave; ..\Drivers\drivers_nrf\uart; ..\Drivers\drivers_nrf\usbd; ..\Drivers\drivers_nrf\wdt; ..\Drivers\libraries\bsp; ..\Drivers\libraries\button; ..\Drivers\libraries\crc16; ..\Drivers\libraries\crc32; ..\Drivers\libraries\csense; ..\Drivers\libraries\csense_drv; ..\Drivers\libraries\ecc; ..\Drivers\libraries\experimental_section_vars; ..\Drivers\libraries\fds; ..\Drivers\libraries\fifo; ..\Drivers\libraries\fstorage; ..\Drivers\libraries\gpiote; ..\Drivers\libraries\hardfault; ..\Drivers\libraries\hci; ..\Drivers\libraries\led_softblink; ..\Drivers\libraries\log; ..\Drivers\libraries\log\src; ..\Drivers\libraries\low_power_pwm; ..\Drivers\libraries\mem_manager; ..\Drivers\libraries\pwm; ..\Drivers\libraries\queue; ..\Drivers\libraries\scheduler; ..\Drivers\libraries\slip; ..\Drivers\libraries\strerror; ..\Drivers\libraries\timer; ..\Drivers\libraries\twi; ..\Drivers\libraries\uart; ..\Drivers\libraries\usbd; ..\Drivers\libraries\usbd\class\audio; ..\Drivers\libraries\usbd\class\cdc; ..\Drivers\libraries\usbd\class\cdc\acm; ..\Drivers\libraries\usbd\class\hid; ..\Drivers\libraries\usbd\class\hid\generic; ..\Drivers\libraries\usbd\class\hid\kbd; ..\Drivers\libraries\usbd\class\hid\mouse; ..\Drivers\libraries\usbd\class\msc; ..\Drivers\libraries\usbd\config; ..\Drivers\libraries\util; ..\Drivers\softdevice\common\softdevice_handler; ..\Drivers\softdevice\s132\headers; ..\Drivers\softdevice\s132\headers\nrf52; ..\Drivers\toolchain; ..\Drivers\toolchain\cmsis\include; ..\Drivers\\external\segger_rtt
  OBJCOPY.OOCOutputFile: BS_emul.hex
  ILINK.IlinkOutputFile: BS_emul.out
  ILINK.IlinkIcfFile: ..\config\ble_app_uart_c_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Core/Src/: brlt_rem_main.c brlt_rem_rc.c
    ../config/: sdk_config.h
  group Application/ma_ble_protocol
    ../Core/Src/ma_ble_protocol/: core_ble.c ma_ble.c ma_ble_nus_c.c ma_updater.c
  group Board Definition
    ../Drivers/boards/: boards.c
  group Board Support
    ../Drivers/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group Device
    ../Drivers/toolchain/iar/: iar_startup_nrf52.s
    ../Drivers/toolchain/: system_nrf52.c
  group nRF_BLE
    ../Drivers/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../Drivers/ble/ble_db_discovery/: ble_db_discovery.c
    ../Drivers/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../Drivers/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_Drivers
    ../Drivers/drivers_nrf/clock/: nrf_drv_clock.c
    ../Drivers/drivers_nrf/common/: nrf_drv_common.c
    ../Drivers/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../Drivers/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../Drivers/drivers_nrf/pwm/: nrf_drv_pwm.c
    ../Drivers/drivers_nrf/timer/: nrf_drv_timer.c
    ../Drivers/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../Drivers/libraries/button/: app_button.c
    ../Drivers/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../Drivers/libraries/fifo/: app_fifo.c
    ../Drivers/libraries/pwm/: app_pwm.c
    ../Drivers/libraries/timer/: app_timer.c
    ../Drivers/libraries/uart/: app_uart_fifo.c retarget.c
    ../Drivers/libraries/fds/: fds.c
    ../Drivers/libraries/fstorage/: fstorage.c
    ../Drivers/libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    ../Drivers/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../Drivers/external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../Drivers/softdevice/common/softdevice_handler/: softdevice_handler.c
