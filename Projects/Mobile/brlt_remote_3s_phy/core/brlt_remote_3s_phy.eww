<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\brlt_remote_3s_phy.ewp</path>
    </project>
    <batchBuild />
</workspace>
