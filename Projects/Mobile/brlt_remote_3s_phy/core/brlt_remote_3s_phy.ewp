# IAR project brlt_remote_3s_phy.ewp, settings and files
configuration BRC_DEBUG (ARM, debug)
  General.OGChipSelectEditMenu: nrf51822_xxaa NordicSemi nRF51822_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG_BUILD; __HEAP_SIZE=0; BLE_STACK_SUPPORT_REQD; BOARD_PCA10028; S130; BSP_UART_SUPPORT; NRF51; NRF51822; SOFTDEVICE_PRESENT; SWI_DISABLE0; NRF_LOG_USES_UART=1
  ICCARM.CCIncludePath2: application; application\platform; application\brlt_ble; application\device; application\device\br3s; application\device\br4s; application\device\brlt; application\device\remote; application\util\timer_drv; application\util\user_data; application\util\indication; application\util\indication\brc_lcd; application\util\custom_srv\ma_ble_nus_c; config; ..\components\bsp; ..\components\ble\peer_manager; ..\components\ble\common; ..\components\ble\ble_services\ble_nus_c; ..\components\ble\ble_db_discovery; ..\components\ble\peer_manager; ..\components\ble\ble_db_discovery; ..\components\ble\nrf_ble_gatt; ..\components\ble\nrf_ble_qwr; ..\components\ble\ble_advertising; ..\components\ble\ble_dtm; ..\components\ble\ble_racp; ..\components\device; ..\components\boards; ..\components\drivers_nrf\common; ..\components\device; ..\components\drivers_nrf\clock; ..\components\drivers_nrf\delay; ..\components\drivers_nrf\gpiote; ..\components\drivers_nrf\hal; ..\components\drivers_nrf\uart; ..\components\drivers_nrf\spi_master; ..\components\drivers_nrf\pstorage; ..\components\drivers_nrf\clock; ..\components\libraries\gpiote; ..\components\libraries\button; ..\components\libraries\fifo; ..\components\libraries\timer; ..\components\libraries\trace; ..\components\libraries\uart; ..\components\libraries\util; ..\components\libraries\log; ..\components\libraries\log\src; ..\components\libraries\fstorage; ..\components\libraries\fds; ..\components\libraries\queue; ..\components\libraries\experimental_section_vars; ..\components\softdevice\common\softdevice_handler; ..\components\softdevice\s130\headers; ..\components\softdevice\s130\headers\nrf51; ..\components\toolchain; ..\components\toolchain\iar; ..\components\toolchain\CMSIS\Include; ..\; ..\external\segger_rtt
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __HEAP_SIZE=0; BLE_STACK_SUPPORT_REQD; S130; BOARD_PCA10028; BSP_UART_SUPPORT; NRF51; SOFTDEVICE_PRESENT; SWI_DISABLE0; NRF_LOG_USES_UART=1
  AARM.AUserIncludes: ..\..\..\config\ble_app_uart_c_s130_pca10028; ..\..\..\config; ..\..\..\..\..\..\components\ble\ble_db_discovery; ..\..\..\..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\..\..\components\softdevice\s130\headers\nrf51; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\CMSIS\Include; ..\..\..\..\..\bsp; ..\..\..\..\..\..\external\segger_rtt
  OBJCOPY.OOCOutputFile: brlt_remote_3s_phy.hex
  prebuild: wscript.exe versionfile-gen.vbs application\platform\debug_version.h $TARGET_DIR$\brc.hex
  postbuild: post-build.bat "$TARGET_BPATH$" "$TARGET_DIR$" "..\components\softdevice\s130\hex\s130_nrf51_2.0.1_softdevice"  & wscript.exe rename_merged_output_hex_debug.vbs application\platform\debug_version.h $TARGET_DIR$\brc.hex $TARGET_DIR$\
  ILINK.IlinkOutputFile: brlt_remote_3s_phy.out
  ILINK.IlinkIcfFile: brlt_remote_3s_phy_iar_nRF5x.icf
  ILINK.IlinkExtraOptions: --log call_graph
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration BRC_RELEASE (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __HEAP_SIZE=0; BLE_STACK_SUPPORT_REQD; BOARD_PCA10028; S130; BSP_UART_SUPPORT; NRF51; NRF51822; SOFTDEVICE_PRESENT; SWI_DISABLE0; NRF_LOG_USES_UART=1
  ICCARM.CCIncludePath2: application; application\platform; application\brlt_ble; application\device; application\device\br3s; application\device\brlt; application\device\br4s; application\device\remote; application\util\timer_drv; application\util\user_data; application\util\indication; application\util\indication\brc_lcd; application\util\custom_srv\ma_ble_nus_c; config; ..\components\bsp; ..\components\ble\peer_manager; ..\components\ble\common; ..\components\ble\ble_services\ble_nus_c; ..\components\ble\ble_db_discovery; ..\components\ble\peer_manager; ..\components\ble\ble_db_discovery; ..\components\ble\nrf_ble_gatt; ..\components\ble\nrf_ble_qwr; ..\components\ble\ble_advertising; ..\components\ble\ble_dtm; ..\components\ble\ble_racp; ..\components\device; ..\components\boards; ..\components\drivers_nrf\common; ..\components\device; ..\components\drivers_nrf\clock; ..\components\drivers_nrf\delay; ..\components\drivers_nrf\gpiote; ..\components\drivers_nrf\hal; ..\components\drivers_nrf\uart; ..\components\drivers_nrf\spi_master; ..\components\drivers_nrf\pstorage; ..\components\drivers_nrf\clock; ..\components\libraries\gpiote; ..\components\libraries\button; ..\components\libraries\fifo; ..\components\libraries\timer; ..\components\libraries\trace; ..\components\libraries\uart; ..\components\libraries\util; ..\components\libraries\log; ..\components\libraries\log\src; ..\components\libraries\fstorage; ..\components\libraries\fds; ..\components\libraries\queue; ..\components\libraries\experimental_section_vars; ..\components\softdevice\common\softdevice_handler; ..\components\softdevice\s130\headers; ..\components\softdevice\s130\headers\nrf51; ..\components\toolchain; ..\components\toolchain\iar; ..\components\toolchain\CMSIS\Include; ..\; ..\external\segger_rtt
  prebuild: wscript.exe versionfile-gen.vbs application\platform\version.h $TARGET_DIR$\brc.hex
  postbuild: post-build.bat "$TARGET_BPATH$" "$TARGET_DIR$" "..\components\softdevice\s130\hex\s130_nrf51_2.0.1_softdevice"  & wscript.exe rename_merged_output_hex.vbs application\platform\version.h $TARGET_DIR$\brc.hex $TARGET_DIR$\
  group Application
    application/: brc_buttons.c BRC_HT16XX_LCD.c BRC_Menu_LCD.c main.c
    config/: sdk_config.h
  group Application/brlt_ble
    application/brlt_ble/: core_ble.c
  group Application/devices/br3s
    application/device/br3s/: br3s_button_reaction.c br3s_main.c br3s_menu.c br3s_protocol.c
  group Application/devices/br4s
    application/device/br4s/: br4s_button_reaction.c br4s_main.c br4s_menu.c br4s_protocol.c
  group Application/devices/brlt
    application/device/brlt/: brlt_button_reaction.c brlt_main.c brlt_menu.c brlt_protocol.c
  group Application/devices/remote
    application/device/remote/: remote_button_reaction.c remote_main.c remote_menu.c remote_protocol.c
  group Application/platform
    application/platform/: platform.h
  group Application/util
    ../components/boards/: boards.h
  group Application/util/custom_srv/ma_ble_nus_c
    application/util/custom_srv/ma_ble_nus_c/: ma_ble_nus_c.c
  group Application/util/indication
    application/util/indication/: indication_interface.h
  group Application/util/indication/brc_lcd
    application/util/indication/brc_lcd/: brc_lcd_ht16xx_driver.c brc_lcd_indication.c brc_lcd_phy.c
  group Application/util/timer_drv
    application/util/timer_drv/: timer_drv.c
  group Application/util/user_data
    application/util/user_data/: user_data.c
  group Device
    ../components/toolchain/iar/: iar_startup_nrf51.s
    ../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
    ../: ChangeLog.txt
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../components/ble/ble_services/ble_nus_c/: ble_nus_c.c
    ../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_Drivers
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../components/libraries/button/: app_button.c
    ../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../components/libraries/fifo/: app_fifo.c
    ../components/libraries/gpiote/: app_gpiote.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../components/libraries/fds/: fds.c
    ../components/libraries/fstorage/: fstorage.c
    ../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
    ../components/libraries/queue/: nrf_queue.c
  group nRF_Segger_RTT
    ../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
